# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\USARTX;..\HARDWARE\JSON;..\HARDWARE\MALLOC;..\HARDWARE\MOTOR;..\HARDWARE\RELAY;..\HARDWARE\TIMER;..\HARDWARE\MASTER_COMMUNICATION;..\HARDWARE\ZMODULE_COMMUNICATION;..\HARDWARE\COMMON_COMMUNICATION;..\HARDWARE\WDG
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/JSON/: cJSON.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MASTER_COMMUNICATION/: master_communication.c
    ../HARDWARE/ZMODULE_COMMUNICATION/: zmodule_communication.c
    ../HARDWARE/COMMON_COMMUNICATION/: common_communication.c
    ../HARDWARE/WDG/: wdg.c
